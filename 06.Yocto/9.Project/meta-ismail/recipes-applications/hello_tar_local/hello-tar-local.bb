LICENSE = "CLOSED"
S = "${WORKDIR}"

SRC_URI = "file://hello_tar_local.tar"

EXTRA_OECMAKE = " "

inherit cmake